// Mock implementations for Adafruit_GFX for Windows builds
#ifndef ARDUINO

#include "Adafruit_GFX.h"

#include "WString.h"

// Simple 5x7 bitmap font (ASCII 32-126)
// Each character is 5 bytes, one byte per column
static const unsigned char font5x7[][5] = {
    {0x00, 0x00, 0x00, 0x00, 0x00}, // space
    {0x00, 0x00, 0x5F, 0x00, 0x00}, // !
    {0x00, 0x07, 0x00, 0x07, 0x00}, // "
    {0x14, 0x7F, 0x14, 0x7F, 0x14}, // #
    {0x24, 0x2A, 0x7F, 0x2A, 0x12}, // $
    {0x23, 0x13, 0x08, 0x64, 0x62}, // %
    {0x36, 0x49, 0x55, 0x22, 0x50}, // &
    {0x00, 0x05, 0x03, 0x00, 0x00}, // '
    {0x00, 0x1C, 0x22, 0x41, 0x00}, // (
    {0x00, 0x41, 0x22, 0x1C, 0x00}, // )
    {0x14, 0x08, 0x3E, 0x08, 0x14}, // *
    {0x08, 0x08, 0x3E, 0x08, 0x08}, // +
    {0x00, 0x50, 0x30, 0x00, 0x00}, // ,
    {0x08, 0x08, 0x08, 0x08, 0x08}, // -
    {0x00, 0x60, 0x60, 0x00, 0x00}, // .
    {0x20, 0x10, 0x08, 0x04, 0x02}, // /
    {0x3E, 0x51, 0x49, 0x45, 0x3E}, // 0
    {0x00, 0x42, 0x7F, 0x40, 0x00}, // 1
    {0x42, 0x61, 0x51, 0x49, 0x46}, // 2
    {0x21, 0x41, 0x45, 0x4B, 0x31}, // 3
    {0x18, 0x14, 0x12, 0x7F, 0x10}, // 4
    {0x27, 0x45, 0x45, 0x45, 0x39}, // 5
    {0x3C, 0x4A, 0x49, 0x49, 0x30}, // 6
    {0x01, 0x71, 0x09, 0x05, 0x03}, // 7
    {0x36, 0x49, 0x49, 0x49, 0x36}, // 8
    {0x06, 0x49, 0x49, 0x29, 0x1E}, // 9
    {0x00, 0x36, 0x36, 0x00, 0x00}, // :
    {0x00, 0x56, 0x36, 0x00, 0x00}, // ;
    {0x08, 0x14, 0x22, 0x41, 0x00}, // <
    {0x14, 0x14, 0x14, 0x14, 0x14}, // =
    {0x00, 0x41, 0x22, 0x14, 0x08}, // >
    {0x02, 0x01, 0x51, 0x09, 0x06}, // ?
    {0x32, 0x49, 0x79, 0x41, 0x3E}, // @
    {0x7E, 0x11, 0x11, 0x11, 0x7E}, // A
    {0x7F, 0x49, 0x49, 0x49, 0x36}, // B
    {0x3E, 0x41, 0x41, 0x41, 0x22}, // C
    {0x7F, 0x41, 0x41, 0x22, 0x1C}, // D
    {0x7F, 0x49, 0x49, 0x49, 0x41}, // E
    {0x7F, 0x09, 0x09, 0x09, 0x01}, // F
    {0x3E, 0x41, 0x49, 0x49, 0x7A}, // G
    {0x7F, 0x08, 0x08, 0x08, 0x7F}, // H
    {0x00, 0x41, 0x7F, 0x41, 0x00}, // I
    {0x20, 0x40, 0x41, 0x3F, 0x01}, // J
    {0x7F, 0x08, 0x14, 0x22, 0x41}, // K
    {0x7F, 0x40, 0x40, 0x40, 0x40}, // L
    {0x7F, 0x02, 0x0C, 0x02, 0x7F}, // M
    {0x7F, 0x04, 0x08, 0x10, 0x7F}, // N
    {0x3E, 0x41, 0x41, 0x41, 0x3E}, // O
    {0x7F, 0x09, 0x09, 0x09, 0x06}, // P
    {0x3E, 0x41, 0x51, 0x21, 0x5E}, // Q
    {0x7F, 0x09, 0x19, 0x29, 0x46}, // R
    {0x46, 0x49, 0x49, 0x49, 0x31}, // S
    {0x01, 0x01, 0x7F, 0x01, 0x01}, // T
    {0x3F, 0x40, 0x40, 0x40, 0x3F}, // U
    {0x1F, 0x20, 0x40, 0x20, 0x1F}, // V
    {0x3F, 0x40, 0x38, 0x40, 0x3F}, // W
    {0x63, 0x14, 0x08, 0x14, 0x63}, // X
    {0x07, 0x08, 0x70, 0x08, 0x07}, // Y
    {0x61, 0x51, 0x49, 0x45, 0x43}, // Z
    {0x00, 0x7F, 0x41, 0x41, 0x00}, // [
    {0x02, 0x04, 0x08, 0x10, 0x20}, // backslash
    {0x00, 0x41, 0x41, 0x7F, 0x00}, // ]
    {0x04, 0x02, 0x01, 0x02, 0x04}, // ^
    {0x40, 0x40, 0x40, 0x40, 0x40}, // _
    {0x00, 0x01, 0x02, 0x04, 0x00}, // `
    {0x20, 0x54, 0x54, 0x54, 0x78}, // a
    {0x7F, 0x48, 0x44, 0x44, 0x38}, // b
    {0x38, 0x44, 0x44, 0x44, 0x20}, // c
    {0x38, 0x44, 0x44, 0x48, 0x7F}, // d
    {0x38, 0x54, 0x54, 0x54, 0x18}, // e
    {0x08, 0x7E, 0x09, 0x01, 0x02}, // f
    {0x0C, 0x52, 0x52, 0x52, 0x3E}, // g
    {0x7F, 0x08, 0x04, 0x04, 0x78}, // h
    {0x00, 0x44, 0x7D, 0x40, 0x00}, // i
    {0x20, 0x40, 0x44, 0x3D, 0x00}, // j
    {0x7F, 0x10, 0x28, 0x44, 0x00}, // k
    {0x00, 0x41, 0x7F, 0x40, 0x00}, // l
    {0x7C, 0x04, 0x18, 0x04, 0x78}, // m
    {0x7C, 0x08, 0x04, 0x04, 0x78}, // n
    {0x38, 0x44, 0x44, 0x44, 0x38}, // o
    {0x7C, 0x14, 0x14, 0x14, 0x08}, // p
    {0x08, 0x14, 0x14, 0x18, 0x7C}, // q
    {0x7C, 0x08, 0x04, 0x04, 0x08}, // r
    {0x48, 0x54, 0x54, 0x54, 0x20}, // s
    {0x04, 0x3F, 0x44, 0x40, 0x20}, // t
    {0x3C, 0x40, 0x40, 0x20, 0x7C}, // u
    {0x1C, 0x20, 0x40, 0x20, 0x1C}, // v
    {0x3C, 0x40, 0x30, 0x40, 0x3C}, // w
    {0x44, 0x28, 0x10, 0x28, 0x44}, // x
    {0x0C, 0x50, 0x50, 0x50, 0x3C}, // y
    {0x44, 0x64, 0x54, 0x4C, 0x44}, // z
    {0x00, 0x08, 0x36, 0x41, 0x00}, // {
    {0x00, 0x00, 0x7F, 0x00, 0x00}, // |
    {0x00, 0x41, 0x36, 0x08, 0x00}, // }
    {0x08, 0x04, 0x08, 0x10, 0x08}, // ~
};

void Adafruit_GFX::print(const char* str) {
  if (!str)
    return;

  if (gfxFont) {
    // Use GFX font
    for (const char* p = str; *p; p++) {
      uint8_t c = *p;

      // Check if character is in font range
      if (c < gfxFont->first || c > gfxFont->last) {
        c = ' ';  // Default to space if out of range
        if (c < gfxFont->first || c > gfxFont->last)
          continue;  // Skip if space is also not available
      }

      c -= gfxFont->first;
      GFXglyph* glyph = &gfxFont->glyph[c];
      uint8_t* bitmap = gfxFont->bitmap;

      uint16_t bo = glyph->bitmapOffset;
      uint8_t w = glyph->width;
      uint8_t h = glyph->height;
      int8_t xo = glyph->xOffset;
      int8_t yo = glyph->yOffset;
      uint8_t bits = 0, bit = 0;

      // Draw the glyph
      for (uint8_t yy = 0; yy < h; yy++) {
        for (uint8_t xx = 0; xx < w; xx++) {
          if (!(bit++ & 7)) {
            bits = bitmap[bo++];
          }
          if (bits & 0x80) {
            drawPixel(cursor_x + xo + xx, cursor_y + yo + yy, textcolor);
          }
          bits <<= 1;
        }
      }

      cursor_x += glyph->xAdvance;
    }
  } else {
    // Use built-in 5x7 font
    for (const char* p = str; *p; p++) {
      char c = *p;

      // Only handle printable ASCII
      if (c < 32 || c > 126) {
        c = ' ';
      }

      // Get the font data for this character
      const unsigned char* glyph = font5x7[c - 32];

      // Draw the character (5 columns)
      for (int col = 0; col < 5; col++) {
        for (int row = 0; row < 8; row++) {
          if (glyph[col] & (1 << row)) {
            // Draw pixel at scaled position
            for (int sy = 0; sy < textsize_y; sy++) {
              for (int sx = 0; sx < textsize_x; sx++) {
                drawPixel(cursor_x + col * textsize_x + sx, cursor_y + row * textsize_y + sy, textcolor);
              }
            }
          }
        }
      }

      // Move cursor (6 pixels per char including 1px spacing)
      cursor_x += 6 * textsize_x;
    }
  }
}

void Adafruit_GFX::print(const String& str) {
  print(str.c_str());
}

void Adafruit_GFX::getTextBounds(const char* str, int16_t x, int16_t y, int16_t* x1, int16_t* y1, uint16_t* w,
                                 uint16_t* h) {
  (void)x;
  (void)y;  // Unused parameters

  if (gfxFont) {
    // GFX font - calculate actual metrics
    int16_t minx = 0, miny = 0, maxx = -1, maxy = -1;
    int16_t cursor_x_temp = 0;

    for (const char* p = str; *p; p++) {
      uint8_t c = *p;

      // Check if character is in font range
      if (c < gfxFont->first || c > gfxFont->last) {
        c = ' ';
        if (c < gfxFont->first || c > gfxFont->last)
          continue;
      }

      c -= gfxFont->first;
      GFXglyph* glyph = &gfxFont->glyph[c];

      int16_t gx1 = cursor_x_temp + glyph->xOffset;
      int16_t gy1 = glyph->yOffset;
      int16_t gx2 = gx1 + glyph->width - 1;
      int16_t gy2 = gy1 + glyph->height - 1;

      if (gx1 < minx)
        minx = gx1;
      if (gy1 < miny)
        miny = gy1;
      if (gx2 > maxx)
        maxx = gx2;
      if (gy2 > maxy)
        maxy = gy2;

      cursor_x_temp += glyph->xAdvance;
    }

    if (maxx >= minx) {
      *x1 = minx;
      *y1 = miny;
      *w = maxx - minx + 1;
      *h = maxy - miny + 1;
    } else {
      // Empty string
      *x1 = 0;
      *y1 = 0;
      *w = 0;
      *h = 0;
    }
  } else {
    // Built-in 5x7 font
    *x1 = 0;
    *y1 = static_cast<int16_t>(-8 * textsize_y);

    // Calculate width based on character count
    int len = 0;
    for (const char* p = str; *p; p++)
      len++;

    *w = static_cast<uint16_t>(len * 6 * textsize_x);  // 6px per character
    *h = static_cast<uint16_t>(8 * textsize_y);        // 8px height
  }
}

#endif  // ARDUINO
